options:
  parameters:
    author: yuri
    generate_options: qt_gui
    id: test_0
    max_nouts: ''
    output_language: python
    title: Listener for RFID system
  states: {}

blocks:
- name: Cen_f
  id: variable
  parameters:
    value: '910250000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '800000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: '1000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/yu/gr-rfid/Test_Listener/decoded_data
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/yu/gr-rfid/examples/gate_test
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/yu/gr-rfid/Test_Listener/output.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1000'
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: '[1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,]'
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '30'
    freq0: Cen_f
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"fre ori"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"after gate"'
    size: '1000000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"after FIR filter"'
    size: '1000000'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"ori"'
    size: '1000000'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"out1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1000000'
    srate: samp_rate
    type: complex
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: samp_rate
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: '2000000'
    sample_rate: '2000000'
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    comment: |-
      out 1:  float
      out 2: complex
    sample_rate: samp_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [osmosdr_source_0, '0', fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [rfid_gate_0, '0', blocks_complex_to_mag_0, '0']
- [rfid_gate_0, '0', blocks_file_sink_1, '0']
- [rfid_gate_0, '0', qtgui_time_sink_x_1, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_null_sink_1, '0']
- [rfid_tag_decoder_0, '0', qtgui_time_sink_x_0_1, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [rfid_tag_decoder_0, '1', blocks_file_sink_0, '0']

metadata:
  file_format: 1
