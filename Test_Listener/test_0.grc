options:
  parameters:
    generate_options: qt_gui
    id: test_0
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '250000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '30'
    freq0: '920375000'
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"fre after lpf"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"after gate"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"after LPF"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"out 1"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"out 2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: samp_rate
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    comment: |-
      out 1:  analogue signal
      out 2: bit stream
    sample_rate: samp_rate
  states: {}

connections:
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rfid_gate_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [rfid_gate_0, '0', qtgui_time_sink_x_0, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_tag_decoder_0, '0', qtgui_time_sink_x_0_1, '0']
- [rfid_tag_decoder_0, '1', qtgui_time_sink_x_0_1_0, '0']

metadata:
  file_format: 1
